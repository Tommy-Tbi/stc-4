# Keil uVision project STC四轴正式版程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC四轴正式版程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 EEPROM.C IMU.C MPU-6050.C NRF24L01.C STC15W4KPWM.C STC四轴正式版程序.C Timer.C USART.C
